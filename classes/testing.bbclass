DEPENDS_prepend = "\
    googletest \
    cppcheck-native \
    "
