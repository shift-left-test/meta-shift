RDEPENDS_${PN} += "\
    fff \
    gmock \
    gtest \
"
