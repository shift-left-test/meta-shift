RDEPENDS:${PN}:append = " \
    nativesdk-cmake \
    nativesdk-python3-gcovr \
    nativesdk-qemu \
"
