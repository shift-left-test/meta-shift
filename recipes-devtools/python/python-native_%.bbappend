RPROVIDES += "\
    python-math-native \
    python-pickle-native \
    python-crypt-native \
    python-debugger-native \
    python-json-native \
    python-argparse-native \
    python-lang-native \
    python-shell-native \
    python-io-native \
    python-netclient-native \
    python-re-native \
    python-pprint-native \
"
