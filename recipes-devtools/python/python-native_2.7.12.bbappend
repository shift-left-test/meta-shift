RPROVIDES_${PN} += "\
    python-crypt-native \
    python-io-native \
    python-lang-native \
    python-math-native \
    python-netclient-native \
    python-pickle-native \
    python-pprint-native \
    python-re-native \
    python-shell-native \
    python-threading-native \
    python-contextlib-native \
"
