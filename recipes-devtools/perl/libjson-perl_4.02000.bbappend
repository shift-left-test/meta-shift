DEPENDS:class-native += "libjson-xs-perl-native"
RDEPENDS:${PN}:class-native += "libjson-xs-perl-native"
