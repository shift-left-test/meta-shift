LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

inherit cmake cmake-testing

SRC_URI = ""
