inherit externalsrc

EXTERNALSRC = "${THISDIR}/../../../sources/cpp-project"
